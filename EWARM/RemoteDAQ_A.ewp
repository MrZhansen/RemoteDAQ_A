# IAR project RemoteDAQ_A.ewp, settings and files
configuration RemoteDAQ_A (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F746xx
  ICCARM.CCIncludePath2: ../Middlewares/Third_Party/LwIP/src/include; ../Drivers/BSP/Components/lan8742; ../Core/Inc; ../Drivers/STM32F7xx_HAL_Driver/Inc; ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F7xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RemoteDAQ_A.hex
  ILINK.IlinkOutputFile: RemoteDAQ_A.out
  ILINK.IlinkIcfFile: stm32f746xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f746xx.s
  group Application/User/Core
    ../Core/Src/: daq_control_stream.c daq_protocol.c digital_sync.c main.c stm32f7xx_hal_msp.c stm32f7xx_it.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c
  group Network (manual, NO_SYS)
    ../Core/Src/: daq_ethernet.c daq_network.c
    ../Middlewares/Third_Party/LwIP/src/core/: def.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c stats.c sys.c timeouts.c udp.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: etharp.c icmp.c ip4.c ip4_addr.c
    ../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
    ../Drivers/BSP/Components/lan8742/: lan8742.c
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_eth.c
